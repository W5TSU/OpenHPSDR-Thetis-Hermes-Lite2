options:
  parameters:
    author: W5TSU
    comment: 'Transmits Tools/FreeDV/radev1_test_iq_long.wav (126.3s of real RADE V1 modem audio, generated by the local freedv-gui checkout''s own TX pipeline -- ''\''freedv -ut tx -utmode RADEV1 -txfile <speech> -txoutfile <modem>\'' -- run 10 times over ~12s chunks of the source speech and concatenated, since a single invocation on the full 112s speech file mysteriously truncated to ~15s of output (not yet root-caused, third-party code -- chunking sidesteps it); then re-synthesized to I/Q via make_fdv_test_iq.py --input-wav --peak-dbfs -6) over the air via HackRF, as a positive-control test of Thetis''s RADE V1 RX chain -- FreeDV-Plan.md Stage C. Generated already at -6 dBFS (learned from the 700E flowgraph''s DAC-quantization bug, see tx_700e_hackrf.grc), so no extra digital gain block needed here. TX gain defaults to 20dB VGA, the level that worked for both the 700E and the first (14.85s) RADE V1 positive control -- raise/lower while watching the spectrum plot and Thetis''s RADE status. Follow Part 97 identification rules: ID at start and end of transmission (this signal is RADE-encoded test speech, not an ID by itself).'
    description: RADE V1 over-the-air positive-control TX test for the HL2/Thetis FreeDV branch
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_radev1_hackrf
    output_language: python
    title: FreeDV RADE V1 -- HackRF TX (positive control)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF TX sample rate -- below ~2 Msps the driver/quality gets unreliable, so this resamples up from the wav's native 48 kHz rather than transmitting at 48 kHz directly. 50x the wav rate, a clean integer interpolation ratio.
    value: wav_samp_rate * 50
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF VGA (IF) gain. Defaults to 20dB, the level that got the 700E positive control to sync -- Part 97 minimum-necessary-power practice still applies, so start here and only raise further if RADE V1 doesn't sync at this level (its signal statistics/bandwidth differ from 700E's).
    gui_hint: 0,1,1,1
    label: TX VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: wav_samp_rate
  id: variable
  parameters:
    comment: Native rate of the I/Q wav (make_fdv_test_iq.py's --rate-out, default 48000)
    value: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: left (I) -> real, right (Q) -> imag -- matches make_fdv_test_iq.py's own left=I/right=Q wav layout.
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Plays once and stops -- no repeat, so this is a single, bounded transmission rather than something that could be left running unattended. 126.3s -- see the top-level comment for how this longer version was built (10 chunked freedv-gui TX runs, concatenated).
    file: in_file
    nchan: '2'
    repeat: 'False'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: 20m ham band, matches the calling frequency used for the earlier off-air RADE V1 monitoring (freedv-calling-frequencies) -- change if you want a different dial frequency, just keep it inside the amateur allocation for your license class.
    label: Center Frequency (Hz)
    type: eng_float
    value: '14236000'
  states: {}
- name: in_file
  id: parameter
  parameters:
    comment: Real RADE V1 modem audio (from freedv-gui's own encoder) re-synthesized to I/Q -- left=I, right=Q, 48 kHz float32, -6 dBFS peak, 126.3s (chunked generation, see the top-level comment). Regenerate per Tools/FreeDV/README.md if missing (gitignored, not committed).
    label: RADE V1 I/Q wav (from make_fdv_test_iq.py --input-wav)
    type: str
    value: '"radev1_w5tsu_singleshot_iq.wav"'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: samp_rate
    comment: RF amp (gain0) left at 0 -- HackRF's front-end amp is a coarse +14dB step, too big a jump for a minimum-necessary-power bench test. Raise tx_gain (VGA) instead, which is the fine-grained slider.
    freq0: center_freq
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: TX-side spectrum monitor, so you can see the signal before it hits the HackRF -- watch this while raising tx_gain. Expect RADE V1's broadband/noise-like signature, not 700E's clean OFDM comb.
    fc: center_freq
    fftsize: '1024'
    name: '"TX spectrum"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz -> samp_rate (2.4 Msps default), so the RADE V1 signal lands safely inside the HackRF's much wider Nyquist band without aliasing.
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    comment: 'Sideband fix, ported from tx_700e_hackrf.grc''s 2026-08-15 finding: make_fdv_test_iq.py''s own conjugate (-iq.imag) was calibrated for Quick-Play''s direct injection point, but the HackRF TX + HL2 RX mixer stages apparently add one more spectral inversion on top of that -- this re-conjugates to cancel it back out and land correctly on USB/DIGU, same as every other place in this repo assumes. Applied here from the start rather than rediscovering the same bug for RADE V1 -- the sideband inversion is a property of the TX/RX hardware chain, not the FreeDV mode, so it should apply identically regardless of what''s being sent.'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
