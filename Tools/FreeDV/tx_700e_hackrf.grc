options:
  parameters:
    author: W5TSU
    comment: 'Transmits Tools/FreeDV/fdv700e_test_iq.wav (a known-good synthetic FreeDV 700E signal, already verified via Quick Play bench testing) over the air via HackRF, as a positive-control test of Thetis''s real RX chain -- FreeDV-Plan.md Phase 3 step 6. TX gain defaults low (VGA=0) -- raise it manually while watching the spectrum plot. Follow Part 97 identification rules: ID at start and end of transmission (this signal is FreeDV-encoded test speech, not an ID by itself).'
    description: 700E over-the-air positive-control TX test for the HL2/Thetis FreeDV branch
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_700e_hackrf
    output_language: python
    title: FreeDV 700E -- HackRF TX (positive control)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF TX sample rate -- below ~2 Msps the driver/quality gets unreliable, so this resamples up from the wav's native 48 kHz rather than transmitting at 48 kHz directly. 50x the wav rate, a clean integer interpolation ratio.
    value: wav_samp_rate * 50
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF VGA (IF) gain. Starts at 0 -- Part 97 minimum-necessary-power practice. Raise gradually while watching the spectrum plot and Thetis's RX, only as far as needed to get a usable signal.
    gui_hint: 0,1,1,1
    label: TX VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: wav_samp_rate
  id: variable
  parameters:
    comment: Native rate of the I/Q wav (make_fdv_test_iq.py's --rate-out, default 48000)
    value: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: left (I) -> real, right (Q) -> imag -- matches make_fdv_test_iq.py's own left=I/right=Q wav layout.
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Plays once and stops -- no repeat, so this is a single, bounded transmission rather than something that could be left running unattended.
    file: in_file
    nchan: '2'
    repeat: 'False'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: 20m ham band, matches the calling frequency used for the earlier off-air RADE V1 monitoring (freedv-calling-frequencies) -- change if you want a different dial frequency, just keep it inside the amateur allocation for your license class.
    label: Center Frequency (Hz)
    type: eng_float
    value: '14236000'
  states: {}
- name: in_file
  id: parameter
  parameters:
    comment: The known-good 700E I/Q test file from Tools/FreeDV/make_fdv_test_iq.py -- left=I, right=Q, 48 kHz float32. Regenerate per Tools/FreeDV/README.md if missing (gitignored, not committed).
    label: 700E I/Q wav (from make_fdv_test_iq.py)
    type: str
    value: '"fdv700e_test_iq.wav"'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: samp_rate
    comment: RF amp (gain0) left at 0 -- HackRF's front-end amp is a coarse +14dB step, too big a jump for a minimum-necessary-power bench test. Raise tx_gain (VGA) instead, which is the fine-grained slider.
    freq0: center_freq
    gain0: '4'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: TX-side spectrum monitor, so you can see the signal before it hits the HackRF -- watch this while raising tx_gain.
    fc: center_freq
    fftsize: '1024'
    name: '"TX spectrum"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 48 kHz -> samp_rate (2.4 Msps default), so the 700E signal (originally placed at +500..+2500 Hz baseband) lands safely inside the HackRF's much wider Nyquist band without aliasing.
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Digital gain fix, not a power/Part-97 control (that''s tx_gain downstream) -- the wav''s -50 dBFS peak was set for Quick-Play''s direct float-sample injection into Thetis (no real DAC involved there). HackRF''s TX DAC is 8-bit, one quantization step = 1/128 = -42 dBFS, so -50 dBFS is *below* the DAC''s own quantization noise floor and the OFDM structure gets crushed before it ever leaves the radio (confirmed by live test: signal visible on the panadapter, but no modulation). 166x = +44.4 dB brings the wav''s ~-50 dBFS peak up to about -6 dBFS, safely inside the DAC''s dynamic range with headroom to avoid clipping.'
    const: '166'
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters:
    comment: 'Sideband fix, found live 2026-08-15: with this signal transmitted over real RF (HackRF TX -> HL2 RX) instead of Quick-Play''s direct injection, it synced on LSB/DIGL instead of the expected USB/DIGU -- make_fdv_test_iq.py''s own conjugate (-iq.imag) was calibrated for Quick-Play''s injection point only, and the HackRF TX + HL2 RX mixer stages apparently add one more spectral inversion on top of that. This block re-conjugates to cancel it back out, landing correctly on USB/DIGU again -- keeps this flowgraph consistent with every other place in this repo that assumes DIGU (README, SKILL.md, make_fdv_test_iq.py''s own docstring), rather than carrying a HackRF-TX-specific LSB exception.'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
