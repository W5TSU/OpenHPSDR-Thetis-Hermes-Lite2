options:
  parameters:
    author: W5TSU
    comment: 'Receives Thetis''s real over-the-air TX output (RADE V1 or FreeDV 700E, whichever the operator has armed via ZZDK/ZZEF and keyed) via HackRF, demodulates it as a standard USB/SSB signal (complex band-pass filter selecting the positive-frequency voice passband, then real part -- the standard software-defined way to do SSB demod when you have full I/Q, no phasing-method analog circuitry needed), and records the result to a mono wav. That wav is the input for an independent decode check: freedv-gui''s own reference decoder (''freedv -ut rx -utmode 700E'' or ''-utmode RADEV1'', see a local freedv-gui checkout) or Tools/FreeDV/make_fdv_test_iq.py''s own analysis conventions -- this flowgraph only captures and demodulates, it does not attempt to decode FreeDV/RADE itself. This is the missing half of the existing tx_700e_hackrf.grc / tx_radev1_hackrf.grc pair (which transmit a known-good signal *into* Thetis''s RX): this one listens to what Thetis''s TX chain actually puts out, closing the ''no off-air decode confirmation'' gap noted throughout FreeDV-Plan.md for both RADE V1 TX and FreeDV 700E TX.'
    description: Off-air capture of Thetis's own RADE V1 / FreeDV 700E TX output, via HackRF RX, for independent reference-decoder confirmation
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rx_offair_capture_hackrf
    output_language: python
    title: Thetis TX Off-Air Capture -- HackRF RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF RX front-end rate. 2 Msps -- comfortably above the ~2 Msps floor the TX flowgraphs found HackRF needs for reliable quality (same hardware, same floor applies to RX), and a clean multiple of audio_rate (250:1) so the frequency-xlating filter's decimation is an exact integer.
    value: '2000000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Output wav rate -- matches freedv_get_modem_sample_rate() for both 700E and RADE V1 (8 kHz) exactly, so the captured audio can be fed straight to freedv-gui's reference decoder with no rate ambiguity (unlike Tools/FreeDV/make_fdv_test_iq.py's --input-wav, which does handle arbitrary rates -- this file is for the reference-decoder path instead, which is pickier).
    value: '8000'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: Must match whatever Thetis is actually transmitting on -- 14.236 MHz / DIGU is this project's established calling frequency for both RADE V1 and 700E testing (see Tools/thetis-ai-control's freedv-calling-frequencies table), same default the TX flowgraphs use. Change if Thetis is tuned elsewhere, but keep this and Thetis's dial frequency identical -- there is no frequency search here, just a fixed-tuned USB demod.
    label: Center Frequency (Hz)
    type: eng_float
    value: '14236000'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF IF (VGA) gain. Thetis's real TX is a strong, close signal compared to typical off-air DX, so this doesn't need the TX flowgraphs' full range -- but an initial live test found 8dB (this flowgraph's original default) too conservative for FreeDV 700E's signal specifically (RADE V1 synced fine at 8dB, 700E didn't sync at all until raised to 24dB) -- 20dB here is a revised starting point from that finding, matching the TX flowgraphs' own default. Watch for a flat-topped/clipped time-domain trace as a sign this or rx_bb_gain is too high, which would corrupt the very thing being verified.
    gui_hint: 0,1,1,1
    label: RX IF/VGA Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: rx_bb_gain
  id: variable_qtgui_range
  parameters:
    comment: HackRF baseband gain -- same start-low guidance as rx_if_gain above.
    gui_hint: 0,2,1,1
    label: RX BB Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: out_file
  id: parameter
  parameters:
    comment: Captured mono USB audio, 8 kHz float32 wav. Rename per capture (this does NOT auto-timestamp) so successive test runs don't overwrite each other -- e.g. offair_tx_radev1_<date>.wav vs offair_tx_700e_<date>.wav, matching this repo's convention of a descriptive name over a bare default (see offair_14236000_RADEV1_20260808.wav).
    label: Output wav (captured demodulated audio)
    type: str
    value: '"offair_capture.wav"'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    type: fc32
    args: '"hackrf=0"'
    sync: sync
    sample_rate: samp_rate
    freq0: center_freq
    gain_mode0: 'False'
    gain0: '0'
    if_gain0: rx_if_gain
    bb_gain0: rx_bb_gain
    comment: RF amp (gain0) left at 0 -- HackRF's front-end amp is a coarse +14dB step. Raise rx_if_gain/rx_bb_gain (the fine-grained VGA/baseband sliders) instead if the signal is weak; lower them if it's overloading (this is a very strong, very close signal -- Thetis's own real TX -- not a weak off-air DX catch).
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: 'USB demod + decimate to audio_rate in one block: a complex band-pass covering only +300..+2700 Hz (the positive-frequency side -- USB) rejects the mirror-image LSB content that a real-valued filter couldn''t distinguish. center_freq=0 since osmosdr_source is already tuned exactly to center_freq (the dial frequency), so no further shift is needed here, only filtering + decimation.'
    center_freq: '0'
    decim: samp_rate // audio_rate
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, 300, 2700, 300)
    type: ccc
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: Taking the real part after a one-sided (positive-frequency-only) complex band-pass IS how software SSB/USB demod works with full I/Q -- no separate phasing-method mixer stage needed.
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    comment: Runs until you press GRC's stop button (unlike the TX flowgraphs, which play a fixed-length wav once and stop automatically -- there's no natural end-of-signal marker on receive, so start this flowgraph, key Thetis's TX per the usual thetisctl --confirm-tx protocol, let the transmission run, then stop this once Thetis unkeys).
    file: out_file
    samp_rate: audio_rate
    format: FORMAT_WAV
    bits_per_sample1: FORMAT_PCM_16
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Wide-view spectrum at the HackRF's native rate, before the USB filter -- confirms the signal is actually present and roughly centred before trusting the demodulated audio. Expect 700E's clean OFDM comb or RADE V1's broadband/noise-like signature, matching the TX flowgraphs' own spectrum-sink comments.
    fc: center_freq
    fftsize: '1024'
    name: '"RX spectrum (wideband, pre-demod)"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Demodulated audio waveform after the USB filter -- watch for a flat-topped/clipped trace as a sign rx_if_gain/rx_bb_gain need lowering (this is a very strong, very close signal, not a weak off-air catch), and for real varying content (not a flat line) as basic confirmation something is actually being received.
    label1: ''''''
    name: '"Demodulated audio"'
    size: audio_rate
    srate: audio_rate
    type: float
    wintype: window.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
